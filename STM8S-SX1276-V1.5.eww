<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S-SX1276-V1.5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


